# IAR project template.ewp, settings and files
configuration template (ARM, debug)
  General.OGChipSelectEditMenu: AT32L021C8T7_v2 ArteryTek AT32L021C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: AT32L021C8T7; USE_STDPERIPH_DRIVER; AT_START_L021_V1
  ICCARM.CCIncludePath2: ..\..\libraries\drivers\inc; ..\..\libraries\cmsis\cm0plus\core_support; ..\..\libraries\cmsis\cm0plus\device_support; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: AT32L021x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cmsis
    ./: startup_at32l021.s
    ../../libraries/cmsis/cm0plus/device_support/: system_at32l021.c
  group firmware
    ../../libraries/drivers/src/: at32l021_adc.c at32l021_can.c at32l021_crc.c at32l021_crm.c at32l021_debug.c at32l021_dma.c at32l021_ertc.c at32l021_exint.c at32l021_flash.c at32l021_gpio.c at32l021_hwdiv.c at32l021_i2c.c at32l021_misc.c at32l021_pwc.c at32l021_scfg.c at32l021_spi.c at32l021_tmr.c at32l021_usart.c at32l021_wdt.c at32l021_wwdt.c
  group user
    ../src/: at32l021_int.c at32l021_wk_config.c main.c
