# IAR project template.ewp, settings and files
configuration template (ARM, debug)
  General.OGChipSelectEditMenu: AT32F426CBT7_v2 ArteryTek AT32F426CBT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F426CBT7; USE_STDPERIPH_DRIVER; AT_START_F426_V1
  ICCARM.CCIncludePath2: ..\..\libraries\drivers\inc; ..\..\libraries\cmsis\cm4\core_support; ..\..\libraries\cmsis\cm4\device_support; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: AT32F426xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cmsis
    ./: startup_at32f422_426.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f422_426.c
  group firmware
    ../../libraries/drivers/src/: at32f422_426_adc.c at32f422_426_can.c at32f422_426_cmp.c at32f422_426_crc.c at32f422_426_crm.c at32f422_426_debug.c at32f422_426_dma.c at32f422_426_ertc.c at32f422_426_exint.c at32f422_426_flash.c at32f422_426_gpio.c at32f422_426_i2c.c at32f422_426_misc.c at32f422_426_pwc.c at32f422_426_scfg.c at32f422_426_spi.c at32f422_426_tmr.c at32f422_426_usart.c at32f422_426_wdt.c at32f422_426_wwdt.c
  group user
    ../src/: at32f422_426_int.c at32f422_426_wk_config.c main.c
